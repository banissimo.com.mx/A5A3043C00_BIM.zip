Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: loft_basin_mixer_with_pop_up_waste.ifc.ifc
Time: 2021-10-29T19:43:26
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal
ePset_BIMobjectScript - LOD: 300
ePset_BIMobject_BO - IfcClassification (BO_ifcclas): Sanitary Terminal
